## boards/shields/yeye/Kconfig.defconfig
```kconfig
if SHIELD_YEYE

config ZMK_KEYBOARD_NAME
    default "yeye"

endif # SHIELD_YEYE
```
